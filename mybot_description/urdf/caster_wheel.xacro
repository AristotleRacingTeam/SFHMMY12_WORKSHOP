Commit message: Update caster_wheel.xacro

File: mybot_description/urdf/caster_wheel.xacro (robot description, xacro)
@@ -33,3 +33,6 @@
     <parent link='base_link'/>
   </joint>
+  <gazebo reference='caster_wheel'>
+    <material>Gazebo/Yellow</material>
+   </gazebo>
 </robot>
