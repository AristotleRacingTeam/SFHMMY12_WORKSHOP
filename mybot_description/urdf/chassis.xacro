Commit message: Update chassis.xacro

File: mybot_description/urdf/chassis.xacro (robot description, xacro)
@@ -43,3 +43,6 @@
     <child link='base_link'/>
   </joint>
+  <gazebo reference='base_link'>
+    <material>Gazebo/Black</material>
+   </gazebo>
 </robot>
