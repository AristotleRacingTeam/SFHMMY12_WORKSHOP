Commit message: Update laser_sensor.xacro

File: mybot_description/urdf/laser_sensor.xacro (robot description, xacro)
@@ -21,3 +21,6 @@
     <parent link='base_link'/>
   </joint>
+   <gazebo reference='laser_sensor'>
+    <material>Gazebo/Yellow</material>
+  </gazebo>
 </robot>
